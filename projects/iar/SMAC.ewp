# IAR project SMAC.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\cpu\cc253x\; ..\..\core\; ..\..\platform\cc2530dk\
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group core
    ../../core/: smac.h
  group core/dev
    ../../core/dev/: io.c io.h led.c led.h
  group core/sys
    ../../core/sys/: clock.h
  group cpu/cc253x
    ../../cpu/cc253x/: cc253x.h compiler.h
  group cpu/cc253x/dev
    ../../cpu/cc253x/dev/: clock.c uart.c uart.h
  group examples/blink
    ../../examples/blink/: blink.c
  group platform/cc2530dk
    ../../platform/cc2530dk/: config.h main.c
  group platform/cc2530dk/dev
    ../../platform/cc2530dk/dev/: button.c leds-arch.c
  group platform/drugdelivery
    ../../platform/drugdelivery/: config.h main.c
